
do_install_append () {
  rm ${D}/usr/share/apache2/htdocs/index.html
}

