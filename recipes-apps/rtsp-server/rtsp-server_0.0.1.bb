require rtsp-server.inc

SRCREV = "${AUTOREV}"

